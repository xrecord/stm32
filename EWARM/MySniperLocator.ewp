# IAR project MySniperLocator.ewp, settings and files
configuration MySniperLocator Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Middlewares\Third_Party\FatFs\src\drivers; ..\Middlewares\Third_Party\FatFs\src; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: MySniperLocator Configuration.out
  ILINK.IlinkIcfFile: MySniperLocator.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s startup_stm32f407xx.s startup_stm32f407xx.s startup_stm32f407xx.s startup_stm32f407xx.s startup_stm32f407xx.s
  group Application/User
    ../Src/: bsp_driver_sd.c fatfs.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_it.c bsp_driver_sd.c main.c fatfs.c stm32f4xx_hal_msp.c stm32f4xx_it.c bsp_driver_sd.c main.c fatfs.c stm32f4xx_hal_msp.c stm32f4xx_it.c bsp_driver_sd.c main.c fatfs.c stm32f4xx_hal_msp.c stm32f4xx_it.c bsp_driver_sd.c main.c fatfs.c stm32f4xx_hal_msp.c stm32f4xx_it.c bsp_driver_sd.c main.c fatfs.c stm32f4xx_hal_msp.c
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rtc.c stm32f4xx_ll_usb.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_adc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rtc.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_adc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rtc.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_adc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rtc.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_adc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rtc.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_adc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c ccsbcs.c syscall.c ccsbcs.c syscall.c ccsbcs.c syscall.c ccsbcs.c syscall.c ccsbcs.c syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c diskio.c ff_gen_drv.c ff.c diskio.c ff_gen_drv.c ff.c diskio.c ff_gen_drv.c ff.c diskio.c ff_gen_drv.c ff.c diskio.c ff_gen_drv.c ff.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c sd_diskio.c sd_diskio.c sd_diskio.c sd_diskio.c sd_diskio.c
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
