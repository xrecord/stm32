# IAR project sd_logger.ewp, settings and files
configuration sd_logger Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\Middlewares\Third_Party\FatFs\src; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: sd_logger Configuration.out
  ILINK.IlinkIcfFile: sd_logger.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
  group Application/User
    ../../Src/: bsp_driver_sd.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_ll_sdmmc.c
  group Middlewares/FatFs
    ../../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
    ../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
